# Keil uVision project base.uvprojx, settings and files
target base (6240000::V6.24::ARMCLANG)
  device: RN8211B_SOC_C Renergy
  pack: Renergy.RN_CM0_Devices.1.1.14
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: base
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RN821x_RN721x_SOC_C=1,HBOX_CONFIG_HEADER=hbox_config.h
  c misc: -Wno-sign-compare -Wno-unused-variable -Wno-unused-parameter -Wno-char-subscripts -Wno-unused-but-set-variable
  c include: .\;..\;..\..\3rdparty\rn8xxx_ll_v1.4.0\inc;..\..\3rdparty\rn821x_rn721x_soc_pack_v1.1.14\cmsis\inc;..\CMSIS;..\..\3rdparty\HCppBox\master\hbox;..\..\3rdparty\HCppBox\master\hbox\cpp;..\FreeRTOS-Port;..\..\3rdparty\Keil_RN8211B_Lib\NVM;..\..\3rdparty\HCppBox\master\hbox\hstandalone\hflashdb\3rdparty\source;..\..\3rdparty\HCppBox\master\hbox\hstandalone\hflashdb\port
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group App
    ../: main.cpp hbox_config.c fal_cfg.c drv_lcd.cpp drv_emu.cpp dlt645.cpp drv_uart0.cpp
    ./: syscalls.c
  group LL
    ../../3rdparty/rn8xxx_ll_v1.4.0/src/: rn8xxx_ll_clktrim.c rn8xxx_ll_common.c rn8xxx_ll_d2f.c rn8xxx_ll_dsp.c rn8xxx_ll_eeprom.c rn8xxx_ll_emu.c rn8xxx_ll_emu_lib.c rn8xxx_ll_flash.c rn8xxx_ll_gpadc_lib.c rn8xxx_ll_gpio.c rn8xxx_ll_iic.c rn8xxx_ll_intc.c rn8xxx_ll_iocnt.c rn8xxx_ll_iso7816.c rn8xxx_ll_kbi.c rn8xxx_ll_lcd.c rn8xxx_ll_lib.c rn8xxx_ll_m2m.c rn8xxx_ll_madc.c rn8xxx_ll_novoltagem.c rn8xxx_ll_rtc.c rn8xxx_ll_rtc_lib.c rn8xxx_ll_sea_aes.c rn8xxx_ll_sea_common.c rn8xxx_ll_sea_ecc.c rn8xxx_ll_sea_hash.c rn8xxx_ll_sea_rsa.c rn8xxx_ll_sea_trng.c rn8xxx_ll_simptc.c rn8xxx_ll_sipeeprom.c rn8xxx_ll_spi.c rn8xxx_ll_sysc.c rn8xxx_ll_sysclk.c rn8xxx_ll_sysoption.c rn8xxx_ll_systickcortexm0.c rn8xxx_ll_tc.c rn8xxx_ll_uart.c rn8xxx_ll_utils.c rn8xxx_ll_wdt.c
  group CMSIS
    ../../3rdparty/rn821x_rn721x_soc_pack_v1.1.14/cmsis/src/: system_rn821x_rn721x_soc.c
    ./: startup_rn821x_rn721x_soc.s
  group HBox
    ../../3rdparty/HCppBox/master/hbox/: h3rdparty.c hcompiler.c hcrypto.c hdefaults.c hdriverframework.c hevent.c hgui.c hlocale.c hmemory.c hnet.c hruntime.c hshell.c hsimulator.c huuid.c
  group HBox_cpp
    ../../3rdparty/HCppBox/master/hbox/cpp/: hchain.cpp hcpprt.cpp hfifo.cpp hloop.cpp hobj.cpp hsim.cpp hsim.mcs51.cpp hslots.cpp hsoftdog.cpp
  group HBox_3rdparty
    ../../3rdparty/HCppBox/master/hbox/h3rdparty/: h3rdparty_argtable3_arg_cmd.c h3rdparty_argtable3_arg_date.c h3rdparty_argtable3_arg_dbl.c h3rdparty_argtable3_arg_dstr.c h3rdparty_argtable3_arg_end.c h3rdparty_argtable3_arg_file.c h3rdparty_argtable3_arg_getopt_long.c h3rdparty_argtable3_arg_hashtable.c h3rdparty_argtable3_arg_int.c h3rdparty_argtable3_arg_lit.c h3rdparty_argtable3_arg_rem.c h3rdparty_argtable3_arg_rex.c h3rdparty_argtable3_arg_str.c h3rdparty_argtable3_arg_utils.c h3rdparty_argtable3_argtable3.c h3rdparty_cjson.c h3rdparty_cjson_port.c h3rdparty_cjsonutils.c h3rdparty_common.c h3rdparty_freebsd_elf_header.c h3rdparty_freertos_kernel_croutine.c h3rdparty_freertos_kernel_event_groups.c h3rdparty_freertos_kernel_heap.c h3rdparty_freertos_kernel_list.c h3rdparty_freertos_kernel_queue.c h3rdparty_freertos_kernel_stream_buffer.c h3rdparty_freertos_kernel_tasks.c h3rdparty_freertos_kernel_timers.c h3rdparty_libfdt_fdt.c h3rdparty_libfdt_fdt_addresses.c h3rdparty_libfdt_fdt_check.c h3rdparty_libfdt_fdt_empty_tree.c h3rdparty_libfdt_fdt_overlay.c h3rdparty_libfdt_fdt_ro.c h3rdparty_libfdt_fdt_rw.c h3rdparty_libfdt_fdt_strerror.c h3rdparty_libfdt_fdt_sw.c h3rdparty_libfdt_fdt_wip.c h3rdparty_libfdt_port.c h3rdparty_libqrencode_bitstream.c h3rdparty_libqrencode_mask.c h3rdparty_libqrencode_mmask.c h3rdparty_libqrencode_mqrspec.c h3rdparty_libqrencode_port.c h3rdparty_libqrencode_qrencode.c h3rdparty_libqrencode_qrinput.c h3rdparty_libqrencode_qrspec.c h3rdparty_libqrencode_rsecc.c h3rdparty_libqrencode_split.c h3rdparty_lz4_lz4.c h3rdparty_lz4_lz4file.c h3rdparty_lz4_lz4frame.c h3rdparty_lz4_lz4hc.c h3rdparty_lz4_port.c h3rdparty_lz4_xxhash.c h3rdparty_mini-rv32ima_port.c h3rdparty_mqtt_packet.c h3rdparty_pb_common.c h3rdparty_pb_decode.c h3rdparty_pb_encode.c h3rdparty_pb_port_msg_main_entry.c h3rdparty_printf.c h3rdparty_softfloat.c h3rdparty_softfp.c h3rdparty_tlsf_port.c h3rdparty_tlsf_tlsf.c h3rdparty_uriparser_UriCommon.c h3rdparty_uriparser_UriCompare.c h3rdparty_uriparser_UriCopy.c h3rdparty_uriparser_UriEscape.c h3rdparty_uriparser_UriFile.c h3rdparty_uriparser_UriIp4.c h3rdparty_uriparser_UriIp4Base.c h3rdparty_uriparser_UriMemory.c h3rdparty_uriparser_UriNormalize.c h3rdparty_uriparser_UriNormalizeBase.c h3rdparty_uriparser_UriParse.c h3rdparty_uriparser_UriParseBase.c h3rdparty_uriparser_UriQuery.c h3rdparty_uriparser_UriRecompose.c h3rdparty_uriparser_UriResolve.c h3rdparty_uriparser_UriSetFragment.c h3rdparty_uriparser_UriSetHostAuto.c h3rdparty_uriparser_UriSetHostCommon.c h3rdparty_uriparser_UriSetHostIp4.c h3rdparty_uriparser_UriSetHostIp6.c h3rdparty_uriparser_UriSetHostIpFuture.c h3rdparty_uriparser_UriSetHostRegName.c h3rdparty_uriparser_UriSetPath.c h3rdparty_uriparser_UriSetPort.c h3rdparty_uriparser_UriSetQuery.c h3rdparty_uriparser_UriSetScheme.c h3rdparty_uriparser_UriSetUserInfo.c h3rdparty_uriparser_UriShorten.c h3rdparty_uriparser_UriVersion.c h3rdparty_Z80_port.c h3rdparty_Z80_Z80.c h3rdparty_zlib_adler32.c h3rdparty_zlib_compress.c h3rdparty_zlib_crc32.c h3rdparty_zlib_deflate.c h3rdparty_zlib_gzclose.c h3rdparty_zlib_gzlib.c h3rdparty_zlib_gzread.c h3rdparty_zlib_gzwrite.c h3rdparty_zlib_infback.c h3rdparty_zlib_inffast.c h3rdparty_zlib_inflate.c h3rdparty_zlib_inftrees.c h3rdparty_zlib_port.c h3rdparty_zlib_trees.c h3rdparty_zlib_uncompr.c h3rdparty_zlib_zutil.c
  group FreeRTOS
    ../FreeRTOS-Port/: mpu_wrappers_v2_asm.c port.c portasm.c
  group RN8211B_Nvm
    ../../3rdparty/Keil_RN8211B_Lib/NVM/: rn821x_nvm.lib nvm.h
  group FlashDB
    ../../3rdparty/HCppBox/master/hbox/hstandalone/hflashdb/3rdparty/: flashdb_fal.c flashdb_fal_flash.c flashdb_fal_partition.c flashdb_fal_rtt.c flashdb_fdb.c flashdb_fdb_file.c flashdb_fdb_kvdb.c flashdb_fdb_tsdb.c flashdb_fdb_utils.c
